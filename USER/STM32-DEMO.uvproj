# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Main_Control_code
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\USER;..\FWlib\inc;..\FWlib\src;..\USERHARDWARE;..\USERHARDWARE\TEMP;..\USERHARDWARE\UART;..\USERHARDWARE\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
    ../USERHARDWARE/TEMP/: tempad.c
    ../USERHARDWARE/UART/: usart.c
    ../USERHARDWARE/: command.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
